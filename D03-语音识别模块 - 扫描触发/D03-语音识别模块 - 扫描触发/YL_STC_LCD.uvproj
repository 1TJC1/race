# Keil uVision project YL_STC_LCD.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15W4K32S4 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0xEFF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: YL_STC_LCD +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\LD3320
  group Source Group 1
    ./: main.c
  group LD3320
    ./LD3320/: LD3320.c
