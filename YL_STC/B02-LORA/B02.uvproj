# Keil uVision project B02.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15W4K32S4 STC
  cpu: IRAM(0-0xFF) XRAM(0-0xEFF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: B02 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\UART2
  group Source Group 1
    ./: main.c
  group uart2
    ./UART2/: uart2.c
