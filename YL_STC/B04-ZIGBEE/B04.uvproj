# Keil uVision project B04.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15W4K32S4 STC
  cpu: IRAM(0-0xFF) XRAM(0-0xEFF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: B04 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\UART2;.\ZIGBEE
  group Source Group 1
    ./: main.c
  group UAER2
    ./UART2/: uart2.c
  group zigbee
    ./ZIGBEE/: zigbee.c
