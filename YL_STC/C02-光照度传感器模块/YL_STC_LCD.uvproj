# Keil uVision project YL_STC_LCD.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15W4K32S4 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0xEFF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: YL_STC_LCD +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\LCD;.\BH1750
  group Source Group 1
    ./: main.c spi.c i2c.c
  group LCD
    ./LCD/: lcd.c lcd_init.c
  group BH1750
    ./BH1750/: bh1750.c
