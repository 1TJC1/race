# Keil uVision project CO2.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15W4K32S4 STC
  cpu: IRAM(0-0xFF) XRAM(0-0xEFF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: CO2 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\LCD;.\UART2
  group Source Group 1
    ./: main.c spi.c
  group LCD
    ./LCD/: lcd.c lcd_init.c
  group uart2
    ./UART2/: uart2.c
