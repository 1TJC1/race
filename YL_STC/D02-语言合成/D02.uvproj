# Keil uVision project D02.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15W4K32S4 STC
  cpu: IRAM(0-0xFF) XRAM(0-0xEFF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: D02 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\XFS5051;.\UART2
  group Source Group 1
    ./: main.c
  group XFS5051
    ./XFS5051/: XFS5051.c
  group UART2
    ./UART2/: uart2.c
